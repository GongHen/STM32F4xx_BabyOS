# Keil uVision project Project.uvprojx, settings and files
target STM32407-BABYOS (6140000::V6.14::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM3240G-EVAL
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32407-BABYOS;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\ov2640;..\..\..\Drivers\BSP\Components\ili9325;..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\Drivers\BSP\Components\cs43l22;..\..\..\Utilities\Log;..\..\..\Utilities\Fonts;..\..\..\Utilities\CPU;..\_config;..\..\BabyOS\bos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32407-BABYOS
    ../../../Drivers/BSP/STM32407-BabyOS/: stm32407_babyos.c stm32407_babyos_io.c
  group Application/MDK-ARM
    ./: startup_stm32f417xx.s startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_exti.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c
  group BabyOS/Core
    ../../BabyOS/bos/core/: b_core.c b_device.c b_queue.c b_sem.c b_task.c b_timer.c
  group BabyOS/Driver
    ../../BabyOS/bos/drivers/: b_drv_mcuflash.c b_drv_spiflash.c
    ../../BabyOS/bos/drivers/sfud/: sfud.c sfud_sfdp.c
  group BabyOS/Module
    ../../BabyOS/bos/modules/: b_mod_adchub.c b_mod_button.c b_mod_error.c b_mod_fs.c b_mod_gui.c b_mod_iap.c b_mod_kv.c b_mod_menu.c b_mod_modbus.c b_mod_param.c b_mod_protocol.c b_mod_pwm.c b_mod_qrcode.c b_mod_select.c b_mod_shell.c b_mod_ssl.c b_mod_state.c b_mod_trace.c b_mod_usb.c b_mod_wifi.c b_mod_xm128.c b_mod_ymodem.c
  group BabyOS/Util
    ../../BabyOS/bos/utils/: b_util_at.c b_util_fifo.c b_util_log.c b_util_lunar.c b_util_memp.c b_util_uart.c b_util_utc.c
  group BabyOS/Hal
    ../../BabyOS/bos/hal/: b_hal.c b_hal_flash.c b_hal_gpio.c b_hal_i2c.c b_hal_it.c b_hal_qspi.c b_hal_rng.c b_hal_uart.c b_hal_spi.c
  group BabyOS/Mcu
    ../../BabyOS/bos/mcu/st/stm32f4xx/: mcu_stm32f4xx_flash.c mcu_stm32f4xx_gpio.c mcu_stm32f4xx_i2c.c mcu_stm32f4xx_it.c mcu_stm32f4xx_qspi.c mcu_stm32f4xx_spi.c mcu_stm32f4xx_uart.c
  group BabyOS/Config
    ../_config/: b_config.h b_device_list.h b_hal_if.h
  group BabyOS/Algorithm
    ../../BabyOS/bos/algorithm/: algo_base64.c algo_crc.c algo_hmac_sha1.c algo_md5.c algo_sort.c algo_utf8_unicode.c
  group BabyOS/Services
    ../../BabyOS/bos/services/: b_srv_protocol.c
  group Doc
    ../: readme.txt
target STM3241G-EVAL (6070000::V6.7::.\ARMCLANG)
  device: STM32F417IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: STM3241G-EVAL
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F417xx,USE_STM324xG_EVAL
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\BSP\STM324xG_EVAL;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Drivers\BSP\Components\ov2640;..\..\..\..\Drivers\BSP\Components\ili9325;..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\Drivers\BSP\Components\cs43l22;..\..\..\..\Utilities\Log;..\..\..\..\Utilities\Fonts;..\..\..\..\Utilities\CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.3.0
